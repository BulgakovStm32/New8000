# Keil uVision project new8000sbV1_sw001.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F070F6Px STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x00008000) IRAM(0x20000000,0x00001800) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: new8000sbV1_sw001 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: .\CMSIS_STM32F0xx\CMSIS\Include;.\CMSIS_STM32F0xx\CMSIS\Device\ST\STM32F0xx\Include;.\CMSIS_STM32F0xx\CMSIS\Device\ST\STM32F0xx\Source\Templates;.\Main;.\MyLib\Application_Layer;.\MyLib\Drivers;.\StartUp;.\MyLib\Sheduler;.\MyLib\FSM
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1800
  group CMSIS
    ./CMSIS_STM32F0xx/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
  group StartUp
    ./StartUp/: startup_stm32f070x6.s
  group Drivers
    ./MyLib/Drivers/: adc_ST.c adc_ST.h crc16.c crc16.h gpio_ST.c gpio_ST.h sys_ST.c sys_ST.h sys_tick_ST.c sys_tick_ST.h uart_ST.c uart_ST.h dma_ST.c dma_ST.h
  group Application
    ./MyLib/Application_Layer/: Blink.c Blink.h Rs485.c Rs485.h SB_SirenBoard.c SB_SirenBoard.h Siren.c Siren.h
  group Main
    ./Main/: main.c main.h
  group Sheduler
    ./MyLib/Sheduler/: Scheduler.c Scheduler.h
  group FSM
    ./MyLib/FSM/: FsmMessage.c FsmMessage.h SwTimers.c SwTimers.h
