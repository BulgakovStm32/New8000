# Keil uVision project new8000FPV2_SWv001.uvproj, settings and files
target New8000FPV2_SWv001 (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: new8000FPV2_SWv001 +hex
  c flags: Optim=1 uC99=1 wLevel=2
  c include: .\Main;.\CMSIS_STM32F1xx\CM3\CoreSupport;.\CMSIS_STM32F1xx\CM3\DeviceSupport\ST\STM32F10x;.\CMSIS_STM32F1xx\CM3\DeviceSupport\ST\STM32F10x\startup\arm;.\MyLib;.\MyLib\Application_Layer;.\MyLib\OS
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group StartUp
    ./: startup_stm32f10x_md.s
  group Main
    ./Main/: main.c main.h
  group CMSIS
    ./CMSIS_STM32F1xx/CM3/CoreSupport/: core_cm3.c
    ./CMSIS_STM32F1xx/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group MyLib
    ./MyLib/: sys_ST.c sys_ST.h spi_ST.c spi_ST.h gpio_ST.c gpio_ST.h sys_tick_ST.c sys_tick_ST.h crc16.c crc16.h timers_ST.c timers_ST.h rtc_ST.c rtc_ST.h lcd12864.c lcd12864.h sm1628.c sm1628.h LogoRoxton.c ascii_wg12864.c ascii_RusText.h uart_ST.h uart_ST.c
  group AppLayer
    ./MyLib/Application_Layer/: LineCheck.c LineCheck.h Relay.c Relay.h Rtc.c Rtc.h MenuLcd12864.c MenuLcd12864.h Buttons.c Buttons.h Led.c Led.h
  group OS
    ./MyLib/OS/: RTOS.c RTOS.h
