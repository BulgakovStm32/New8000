# Keil uVision project STM32F103_NEW8000FPV2_SWv003.uvprojx, settings and files
target New8000FPV2_SWv003 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103R8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x00010000) IRAM(0x20000000,0x00005000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103_NEW8000FPV2_SWv003 +hex
  c flags: Optim=1 uC99=1 wLevel=2
  c include: .\Main;.\CMSIS_STM32F1xx\CM3\CoreSupport;.\CMSIS_STM32F1xx\CM3\DeviceSupport\ST\STM32F10x;.\StartUp;.\MyLib;.\MyLib\Application_Layer;.\MyLib\OS;.\Boards\SB_SirenBoard;.\Boards\MB_MotherBoard;.\Boards\FP_FacePanel;.\MyDebug;.\MyLib\FSM
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group StartUp
    ./StartUp/: startup_stm32f10x_md.s
  group CMSIS
    ./CMSIS_STM32F1xx/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ./CMSIS_STM32F1xx/CM3/CoreSupport/: core_cm3.c
  group Main
    ./Main/: main.c main.h
  group MyLib
    ./MyLib/: ascii_lm6063.c ascii_RusText.h ascii_wg12864.c crc16.c crc16.h gpio_ST.c gpio_ST.h lcd12864.c lcd12864.h LogoRoxton.c rtc_ST.c rtc_ST.h sm1628.c sm1628.h spi_ST.c spi_ST.h sys_ST.c sys_ST.h sys_tick_ST.c sys_tick_ST.h timers_ST.c timers_ST.h uart_ST.c uart_ST.h
  group AppLayer
    ./MyLib/Application_Layer/: Buttons.c Buttons.h Led.c Led.h MenuLcd12864.c MenuLcd12864.h Rtc.c Rtc.h Rs485.c Rs485.h Blink.c Blink.h Faults.c Faults.h
  group OS
    ./MyLib/OS/: RTOS.c RTOS.h
  group MB_MotherBoard
    ./Boards/MB_MotherBoard/: MB_MotherBoard.c MB_MotherBoard.h
  group FP_FacePanel
    ./Boards/FP_FacePanel/: FP_FacePanel.c FP_FacePanel.h
  group SB_SirenBoard
    ./Boards/SB_SirenBoard/: SB_SirenBoard.c SB_SirenBoard.h
  group MyDebug
    ./MyDebug/: MyDebug.c MyDebug.h
  group FSM
    ./MyLib/FSM/: SwTimers.c SwTimers.h FsmMessage.c FsmMessage.h
