# Keil uVision project STM32F103_NEW8000FPV2_SWv002.uvproj, settings and files
target New8000FPV2_SWv002 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103R8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32F103_NEW8000FPV2_SWv002 +hex
  c flags: Optim=1
  c include: .\Main;.\CMSIS_STM32F1xx\CM3\CoreSupport;.\CMSIS_STM32F1xx\CM3\DeviceSupport\ST\STM32F10x;.\StartUp;.\MyLib;.\MyLib\Application_Layer;.\MyLib\OS
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group StartUp
    ./StartUp/: startup_stm32f10x_md.s
  group CMSIS
    ./CMSIS_STM32F1xx/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ./CMSIS_STM32F1xx/CM3/CoreSupport/: core_cm3.c
  group Main
    ./Main/: main.c
  group MyLib
    ./MyLib/: adc_ST.c adc_ST.h ascii_lm6063.c ascii_RusText.h ascii_st7565p.c ascii_wg12864.c crc16.c crc16.h gpio_ST.c gpio_ST.h lcd_3_Wire.c lcd_3_Wire.h lcd12864.c lcd12864.h LM6063D.c LM6063D.h LogoRoxton.c rtc_ST.c rtc_ST.h sm1628.c sm1628.h spi_ST.c spi_ST.h symtable.c sys_ST.c sys_ST.h sys_tick_ST.c sys_tick_ST.h timers_ST.c timers_ST.h uart_ST.c uart_ST.h
  group AppLayer
    ./MyLib/Application_Layer/: Buttons.c Buttons.h Led.c Led.h LineCheck.c LineCheck.h MenuLcd12864.c MenuLcd12864.h Relay.c Relay.h Rtc.c Rtc.h
  group OS
    ./MyLib/OS/: RTOS.c RTOS.h
