# Keil uVision project STM32F103_NEW8000FPV2_SWv004.uvproj, settings and files
target STM32F103_NEW8000FPV2_SWv004 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32F103_NEW8000FPV2_SWv004 +hex
  c flags: Optim=1 uC99=1 wLevel=2
  c include: .\CMSIS_STM32F1xx\CM3\CoreSupport;.\CMSIS_STM32F1xx\CM3\DeviceSupport\ST\STM32F10x;.\My\Application;.\My\Boards\FP_FacePanel;.\My\Boards\MB_MotherBoard;.\My\Boards\SB_SirenBoard;.\My\Drivers;.\My\FSM;.\My\Main;.\My\Sheduler;.\My\StartUp;.\AnotherLib
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group StartUp
    ./My/StartUp/: startup_stm32f10x_md.s
  group CMSIS
    ./CMSIS_STM32F1xx/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c system_stm32f10x.h
  group Sheduler
    ./My/Sheduler/: Scheduler.c Scheduler.h
  group Drivers
    ./My/Drivers/: ascii_lm6063.c ascii_RusText.h ascii_wg12864.c crc16.c crc16.h gpio_ST.c gpio_ST.h lcd12864.c lcd12864.h LogoRoxton.c rtc_ST.c rtc_ST.h sm1628.c sm1628.h spi_ST.c spi_ST.h sys_ST.c sys_ST.h sys_tick_ST.c sys_tick_ST.h timers_ST.c timers_ST.h uart_ST.c uart_ST.h
  group Application
    ./My/Application/: Blink.c Blink.h Buttons.c Buttons.h Faults.c Faults.h Led.c Led.h Rs485.c Rs485.h Rtc.c Rtc.h Lcd.c Lcd.h LcdMenu.c LcdMenu.h
  group FSM
    ./My/FSM/: FsmMessage.c FsmMessage.h SwTimers.c SwTimers.h
  group Main
    ./My/Main/: main.c main.h
  group Boards
    ./My/Boards/FP_FacePanel/: FP_FacePanel.c FP_FacePanel.h
    ./My/Boards/MB_MotherBoard/: MB_MotherBoard.c MB_MotherBoard.h
    ./My/Boards/SB_SirenBoard/: SB_SirenBoard.c SB_SirenBoard.h
