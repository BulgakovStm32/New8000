# Keil uVision project new8000MBv1.uvproj, settings and files
target New8000MBV1_SWv001 (ARM-ADS)
  device: STM32F100C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: new8000MBv1 +hex
  c flags: Optim=1 wLevel=2
  c include: ..\NEW8000MBV1rab;.\Main;.\CMSIS_STM32F1xx\CM3\CoreSupport;.\CMSIS_STM32F1xx\CM3\DeviceSupport\ST\STM32F10x;.\CMSIS_STM32F1xx\CM3\DeviceSupport\ST\STM32F10x\startup\arm;.\MyLib;.\MyLib\Application_Layer;.\MyLib\OS
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group StartUp
    ./: startup_stm32f10x_md_vl.s
  group Main
    ./Main/: main.c main.h
  group CMSIS
    ./CMSIS_STM32F1xx/CM3/CoreSupport/: core_cm3.c
    ./CMSIS_STM32F1xx/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group MyLib
    ./MyLib/: lcd_3_Wire.c uart_ST.c sys_ST.c sys_ST.h spi_ST.c spi_ST.h uart_ST.h gpio_ST.c gpio_ST.h sys_tick_ST.c sys_tick_ST.h lcd_3_Wire.h crc16.c crc16.h adc_ST.c adc_ST.h timers_ST.c timers_ST.h rtc_ST.c rtc_ST.h
  group AppLayer
    ./MyLib/Application_Layer/: LineCheck.c LineCheck.h Relay.c Relay.h Rtc.c Rtc.h Eep.c Eep.h Buttons.c Buttons.h
  group OS
    ./MyLib/OS/: RTOS.c RTOS.h
