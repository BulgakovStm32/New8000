# Keil uVision project NEW8000MBV2_SWv003.uvproj, settings and files
target NEW8000MBV2_SWv003 (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: NEW8000MBV2_SWv003 +hex
  c flags: Optim=1 uC99=1
  c include: .\My\Application;.\My\Drivers;.\My\FSM;.\My\Main;.\My\Sheduler;.\My\StartUp;.\My\Boards\FP_FacePanel;.\My\Boards\MB_MotherBoard;.\My\Boards\SB_SirenBoard;.\CMSIS_STM32F1xx\CM3\CoreSupport;.\CMSIS_STM32F1xx\CM3\DeviceSupport\ST\STM32F10x;.\AnotherLib
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group StartUp
    ./My/StartUp/: startup_stm32f10x_md.s
  group CMSIS
    ./CMSIS_STM32F1xx/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Sheduler
    ./My/Sheduler/: Scheduler.c Scheduler.h
  group Drivers
    ./My/Drivers/: adc_ST.c adc_ST.h crc16.c crc16.h dma_ST.c dma_ST.h gpio_ST.c gpio_ST.h lcd_3_Wire.c lcd_3_Wire.h rtc_ST.c rtc_ST.h sys_ST.c sys_ST.h sys_tick_ST.c sys_tick_ST.h timers_ST.c timers_ST.h uart_ST.c uart_ST.h spi_ST.c spi_ST.h
  group Application
    ./My/Application/: Amplifier.c Amplifier.h Blink.c Blink.h Buttons.c Buttons.h Config.c Config.h Faults.c Faults.h Jq6500.c Jq6500.h LineCheck.c LineCheck.h Logging.c Logging.h PojLine.c PojLine.h PowerAndCharge.c PowerAndCharge.h Relay.c Relay.h Rs485.c Rs485.h Time.c Time.h AnalogSwitch.c AnalogSwitch.h Zummer.c Zummer.h EepM95128.c EepM95128.h
  group FSM
    ./My/FSM/: FsmMessage.c FsmMessage.h SwTimers.c SwTimers.h
  group Main
    ./My/Main/: main.c main.h
  group Boards
    ./My/Boards/FP_FacePanel/: FP_FacePanel.c FP_FacePanel.h
    ./My/Boards/MB_MotherBoard/: MB_MotherBoard.c MB_MotherBoard.h
    ./My/Boards/SB_SirenBoard/: SB_SirenBoard.c SB_SirenBoard.h
