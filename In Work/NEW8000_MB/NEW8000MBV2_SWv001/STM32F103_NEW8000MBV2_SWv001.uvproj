# Keil uVision project STM32F103_NEW8000MBV2_SWv001.uvproj, settings and files
target stm32f103_new8000MBv2_sw001 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32F103_NEW8000MBV2_SWv001 +hex
  c flags: Optim=1 uC99=1
  c include: .\Main;.\MyLib;.\MyLib\Application_Layer;.\MyLib\OS;.\StartUp;.\CMSIS_STM32F1xx\CM3\CoreSupport;.\CMSIS_STM32F1xx\CM3\DeviceSupport\ST\STM32F10x
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ./CMSIS_STM32F1xx/CM3/DeviceSupport/ST/STM32F10x/: stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group StartUp
    ./StartUp/: startup_stm32f10x_md.s
  group Main
    ./Main/: main.c main.h
  group MyLib
    ./MyLib/: adc_ST.c adc_ST.h crc16.c crc16.h gpio_ST.c gpio_ST.h lcd_3_Wire.c lcd_3_Wire.h rtc_ST.c rtc_ST.h spi_ST.c spi_ST.h sys_ST.c sys_ST.h sys_tick_ST.c sys_tick_ST.h timers_ST.c timers_ST.h uart_ST.c uart_ST.h
  group OS
    ./MyLib/OS/: RTOS.c RTOS.h
  group AppLay
    ./MyLib/Application_Layer/: Amplifier.c Amplifier.h Buttons.c Buttons.h Eep.c Eep.h Jq6500.c Jq6500.h LineCheck.c LineCheck.h PowerAndCharge.c PowerAndCharge.h Relay.c Relay.h Rtc.c Rtc.h VirtMachine.c VirtMachine.h Rs485.c Rs485.h SB_SirenBoard.c SB_SirenBoard.h
